# Autodesk Inventor assembly: 28.0083
## iProperties
Created: 2006-12
Part Number: 28.0083
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
